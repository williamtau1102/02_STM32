# Keil uVision project Beep.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\Version 5.06)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Beep +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE
  c include: ..\Driver\CMSIS\Device\ST\STM32F1xx\Include;..\Driver\CMSIS\Include;..\Driver;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../User/: stm32f1xx_it.c system_stm32f1xx.c
    ./: main.c
  group Drivers/SYSTEM
    ../Driver/SYSTEM/delay/: delay.c
    ../Driver/SYSTEM/sys/: sys.c
    ../Driver/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
